# Keil uVision project drv_systick_delay.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: drv_systick_delay +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\includes
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./: main.c drv_systick-delay.c
  group inc
    ./: drv_systick-delay.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
